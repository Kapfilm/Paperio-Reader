#include "KakuroGameActivity.h"
#include <Arduino.h>
#include <I18n.h>
#include <algorithm>
#include <cstdio>
#include <memory>
#include "KakuroMenuActivity.h"
#include "KakuroStore.h"
#include "KakuroLayout.h"
#include "UiFonts.h"
#include "components/UITheme.h"
#include "fontIds.h"
namespace {constexpr int small=STATUS_LARGE_FONT_ID;}
KakuroGameActivity::KakuroGameActivity(GfxRenderer&r,MappedInputManager&i,KakuroBoard::Difficulty d,bool resume):Activity("Kakuro",r,i),resumeRequested(resume),difficulty(d){}
void KakuroGameActivity::firstCell(){for(int r=0;r<board.rows;++r)for(int c=0;c<board.columns;++c)if(board.isPlayable(r,c)){cursorRow=r;cursorColumn=c;return;}}
void KakuroGameActivity::onEnter(){Activity::onEnter();renderer.setOrientation(GfxRenderer::Portrait);KakuroSaveSlot slot;if(resumeRequested&&KakuroStore::load(slot)){board=slot.board;difficulty=slot.difficulty;variant=slot.variant;cursorRow=slot.cursorRow;cursorColumn=slot.cursorColumn;elapsedMs=uint32_t(slot.elapsedSec)*1000;}else{auto s=KakuroStore::loadStats();variant=s.positions[int(difficulty)];board.build(difficulty,variant);firstCell();KakuroStore::recordStart(difficulty);}{auto s=KakuroStore::loadStats();for(int i=0;i<3;++i)solvedCounts[i]=s.completedCount[i];}lastTickMs=millis();if(board.isSolved())state=State::Won;requestUpdate();}
void KakuroGameActivity::onExit(){flushSave();Activity::onExit();}
void KakuroGameActivity::scheduleSave(){saveDebouncer.schedule(millis());}
bool KakuroGameActivity::flushSave(){saveDebouncer.clear();KakuroSaveSlot s;s.board=board;s.difficulty=difficulty;s.variant=variant;s.cursorRow=cursorRow;s.cursorColumn=cursorColumn;s.elapsedSec=std::min<uint32_t>(65535,elapsedMs/1000);saveFailed=!KakuroStore::save(s);return !saveFailed;}
void KakuroGameActivity::resume(){state=State::Playing;lastTickMs=millis();requestUpdate();}
void KakuroGameActivity::openPuzzle(int n){if(!flushSave())return;variant=(n+200)%200;board.build(difficulty,variant);firstCell();palette=false;elapsedMs=0;auto s=KakuroStore::loadStats();s.positions[int(difficulty)]=variant;KakuroStore::saveStats(s);KakuroStore::recordStart(difficulty);flushSave();resume();}
void KakuroGameActivity::solve(){KakuroStore::recordCompletion(difficulty,std::max<uint32_t>(1,std::min<uint32_t>(65535,elapsedMs/1000)),variant);flushSave();{auto s=KakuroStore::loadStats();for(int i=0;i<3;++i)solvedCounts[i]=s.completedCount[i];}state=State::Won;palette=false;}
void KakuroGameActivity::useHint(){uint8_t previous[64];std::copy(board.hinted,board.hinted+64,previous);if(board.hint(cursorRow,cursorColumn)){for(int i=0;i<64;++i)if(board.hinted[i]&&!previous[i]){cursorRow=i/8;cursorColumn=i%8;break;}scheduleSave();if(board.isSolved())solve();}}
void KakuroGameActivity::moveCursor(int dr,int dc){int r=cursorRow,c=cursorColumn;for(int tries=0;tries<64;++tries){r=(r+dr+board.rows)%board.rows;c=(c+dc+board.columns)%board.columns;if(board.isPlayable(r,c)){cursorRow=r;cursorColumn=c;scheduleSave();return;}}}
void KakuroGameActivity::loop(){using B=MappedInputManager::Button;
 if(state==State::Playing){auto now=millis();elapsedMs+=now-lastTickMs;lastTickMs=now;if(saveDebouncer.consumeIfDue(now))flushSave();
 if(mappedInput.wasReleased(B::Back)){if(palette)palette=false;else{state=State::GameMenu;selected=0;}requestUpdate();return;}
 if(mappedInput.wasPressed(B::Up)||mappedInput.wasPressed(B::Down)||mappedInput.wasPressed(B::Left)||mappedInput.wasPressed(B::Right)){
 int dr=mappedInput.wasPressed(B::Up)?-1:mappedInput.wasPressed(B::Down)?1:0,dc=mappedInput.wasPressed(B::Left)?-1:mappedInput.wasPressed(B::Right)?1:0;
 if(palette)paletteIndex=((paletteIndex/5+dr+2)%2)*5+(paletteIndex%5+dc+5)%5;else moveCursor(dr,dc);requestUpdate();
 }else if(mappedInput.wasReleased(B::Confirm)){if(palette){board.place(cursorRow,cursorColumn,paletteIndex==9?0:paletteIndex+1);palette=false;scheduleSave();if(board.isSolved())solve();}else if(!board.isHinted(cursorRow,cursorColumn)){palette=true;paletteIndex=board.value(cursorRow,cursorColumn)?board.value(cursorRow,cursorColumn)-1:0;}requestUpdate();}return;}
 if(state==State::Won){if(mappedInput.wasReleased(B::Confirm)){openPuzzle(variant+1);requestUpdate();}else if(mappedInput.wasReleased(B::Back)&&flushSave())activityManager.replaceActivity(std::make_unique<KakuroMenuActivity>(renderer,mappedInput));return;}
 if(state==State::Rules||state==State::Combinations){if(mappedInput.wasReleased(B::Back)){state=State::GameMenu;requestUpdate();return;}if(mappedInput.wasPressed(B::Up)){scroll=std::max(0,scroll-1);requestUpdate();}if(mappedInput.wasPressed(B::Down)||mappedInput.wasReleased(B::Confirm)){++scroll;requestUpdate();}return;}
 if(state==State::ConfirmRestart){if(mappedInput.wasReleased(B::Confirm)){board.resetUser();elapsedMs=0;firstCell();flushSave();resume();}else if(mappedInput.wasReleased(B::Back)){state=State::GameMenu;requestUpdate();}return;}
 const int count=state==State::Levels?3:MenuCount;navigator.onPrevious([&]{selected=(selected+count-1)%count;requestUpdate();});navigator.onNext([&]{selected=(selected+1)%count;requestUpdate();});if(mappedInput.wasReleased(B::Confirm)){activate();requestUpdate();}else if(mappedInput.wasReleased(B::Back)){resume();}}
void KakuroGameActivity::activate(){if(state==State::Levels){if(!flushSave())return;difficulty=static_cast<KakuroBoard::Difficulty>(selected);variant=KakuroStore::loadStats().positions[selected];board.build(difficulty,variant);firstCell();palette=false;elapsedMs=0;flushSave();resume();return;}
 if(selected==2){board.undo();scheduleSave();resume();return;}
 int action=selected>2?selected-1:selected;switch(action){case 0:resume();break;case 1:useHint();if(state!=State::Won)resume();break;case 2:state=State::Combinations;scroll=0;break;case 3:openPuzzle(variant+1);break;case 4:openPuzzle(variant-1);break;case 5:state=State::Levels;selected=int(difficulty);break;case 6:state=State::ConfirmRestart;break;case 7:state=State::Rules;scroll=0;break;case 8:if(flushSave())activityManager.replaceActivity(std::make_unique<KakuroMenuActivity>(renderer,mappedInput));break;}}
const char*KakuroGameActivity::difficultyName(KakuroBoard::Difficulty d){return I18N.get(d==KakuroBoard::Difficulty::Easy?StrId::STR_SUDOKU_DIFFICULTY_EASY:d==KakuroBoard::Difficulty::Medium?StrId::STR_SUDOKU_DIFFICULTY_MEDIUM:StrId::STR_SUDOKU_DIFFICULTY_HARD);}
void KakuroGameActivity::buttons(const char*b,const char*c,const char*u,const char*d){auto l=mappedInput.mapLabels(b,c,u,d);GUI.drawButtonHints(renderer,l.btn1,l.btn2,l.btn3,l.btn4,true);}
void KakuroGameActivity::render(RenderLock&&){renderer.setOrientation(GfxRenderer::Portrait);renderer.clearScreen();if(state==State::Playing)renderPlaying();else if(state==State::GameMenu||state==State::Levels)renderList();else if(state==State::Won)renderWon();else renderText();renderer.displayBuffer(HalDisplay::FAST_REFRESH);}
void KakuroGameActivity::drawHeader(){renderer.drawText(UI_12_FONT_ID,16,10,tr(STR_KAKURO_TITLE),true,EpdFontFamily::BOLD);char b[100];snprintf(b,sizeof(b),"%s · %u / 200 · %s %u",difficultyName(difficulty),unsigned(variant+1),tr(STR_KAKURO_COMPLETED),unsigned(solvedCounts[int(difficulty)]));renderer.drawText(small,16,44,saveFailed?tr(STR_KAKURO_SAVE_FAILED):b);renderer.drawLine(16,70,renderer.getScreenWidth()-16,70,2,true);}
std::string KakuroGameActivity::runText(bool across)const{auto run=board.runFor(cursorRow,cursorColumn,across);if(!run.count)return {};char b[64];snprintf(b,sizeof(b),"%s %u / %u: ",I18N.get(across?StrId::STR_KAKURO_ACROSS:StrId::STR_KAKURO_DOWN),unsigned(run.sum),unsigned(run.count));std::string text=b;auto combos=KakuroBoard::combinations(run.count,run.sum);for(size_t i=0;i<combos.size();++i){if(i)text+=" · ";text+=combos[i];}return text;}
void KakuroGameActivity::renderPlaying(){drawHeader();drawGrid();drawPalette();buttons(palette?tr(STR_KAKURO_CANCEL):tr(STR_KAKURO_MENU),palette?tr(STR_KAKURO_PLACE):tr(STR_KAKURO_PICK_NUMBER),tr(STR_DIR_LEFT),tr(STR_DIR_RIGHT));}
void KakuroGameActivity::drawGrid(){const auto&m=UITheme::getInstance().getMetrics();const int w=renderer.getScreenWidth(),h=renderer.getScreenHeight(),lh=renderer.getLineHeight(small);auto v=kakuro_ui::layout(w,h,board.rows,board.columns,lh,m.buttonHintsHeight);const int font=v.cell<48?UI_12_FONT_ID:NOTOSANS_16_FONT_ID;const auto outside=kakuro_ui::outsideBlocks(board);
 for(int r=0;r<board.rows;++r)for(int c=0;c<board.columns;++c){int x=v.left+c*v.cell,y=v.top+r*v.cell,cell=KakuroBoard::idx(r,c);if(!board.playable[cell]){auto right=board.clueRight[cell],down=board.clueDown[cell];if(!right&&!down){if(!outside[cell]){renderer.drawRect(x,y,v.cell,v.cell,2,true);renderer.drawRect(x+4,y+4,v.cell-8,v.cell-8,true);}continue;}renderer.drawRect(x,y,v.cell,v.cell,2,true);renderer.drawRect(x+4,y+4,v.cell-8,v.cell-8,true);renderer.drawLine(x+2,y+2,x+v.cell-3,y+v.cell-3,2,true);char b[4];if(right){snprintf(b,sizeof(b),"%u",right);renderer.drawText(UI_HINT_FONT_ID,x+v.cell-renderer.getTextWidth(UI_HINT_FONT_ID,b)-3,y+2,b);}if(down){snprintf(b,sizeof(b),"%u",down);renderer.drawText(UI_HINT_FONT_ID,x+3,y+v.cell-renderer.getLineHeight(UI_HINT_FONT_ID)-2,b);}continue;}
 bool active=r==cursorRow&&c==cursorColumn;renderer.drawRect(x,y,v.cell,v.cell,2,true);if(active)renderer.drawRect(x+3,y+3,v.cell-6,v.cell-6,2,true);auto digit=board.user[cell];if(digit){char b[2]={char('0'+digit),0};int tw=renderer.getTextWidth(font,b);int ty=y+(v.cell-renderer.getLineHeight(font))/2;renderer.drawText(font,x+(v.cell-tw)/2,ty,b);if(board.isHinted(r,c))renderer.fillRect(x+(v.cell-tw)/2,ty+renderer.getLineHeight(font)-3,tw,2,true);if(board.hasError(r,c)){renderer.drawLine(x+6,y+6,x+v.cell-7,y+v.cell-7,2,true);renderer.drawLine(x+v.cell-7,y+6,x+6,y+v.cell-7,2,true);}}}
 std::vector<std::string> preview;
 for(bool across:{true,false}){
  auto text=runText(across);
  auto lines=renderer.wrappedText(small,text.c_str(),w-32,100);
  for(size_t i=0;i<std::min<size_t>(3,lines.size());++i){
   auto line=lines[i];
   if(i==2&&lines.size()>3)line=renderer.truncatedText(small,(line+"…").c_str(),w-32);
   preview.push_back(std::move(line));
  }
 }
 int y=kakuro_ui::hintBlockTop(v.paletteY,lh,preview.size());
 for(const auto&line:preview){renderer.drawText(small,16,y,line.c_str());y+=lh;}

}
void KakuroGameActivity::drawPalette(){auto&m=UITheme::getInstance().getMetrics();const int w=renderer.getScreenWidth();auto v=kakuro_ui::layout(w,renderer.getScreenHeight(),board.rows,board.columns,renderer.getLineHeight(small),m.buttonHintsHeight);int left=(w-v.paletteCell*5)/2;for(int i=0;i<10;++i){int x=left+(i%5)*v.paletteCell,y=v.paletteY+(i/5)*46;bool active=palette&&i==paletteIndex;if(active)renderer.fillRect(x+2,y+2,v.paletteCell-4,42,true);renderer.drawRect(x+2,y+2,v.paletteCell-4,42,2,true);char b[2]={i==9?'X':char('1'+i),0};renderer.drawText(UI_12_FONT_ID,x+(v.paletteCell-renderer.getTextWidth(UI_12_FONT_ID,b))/2,y+7,b,!active);}}
void KakuroGameActivity::renderList(){const auto&m=UITheme::getInstance().getMetrics();int w=renderer.getScreenWidth(),y=m.topPadding+m.headerHeight+m.verticalSpacing;GUI.drawHeader(renderer,Rect{0,m.topPadding,w,m.headerHeight},I18N.get(state==State::Levels?StrId::STR_KAKURO_DIFFICULTY:StrId::STR_GAME_GAME_MENU));constexpr StrId ids[]={StrId::STR_GAME_RESUME,StrId::STR_KAKURO_USE_HINT,StrId::STR_KAKURO_UNDO,StrId::STR_KAKURO_COMBINATIONS,StrId::STR_KAKURO_NEXT,StrId::STR_KAKURO_PREVIOUS,StrId::STR_KAKURO_DIFFICULTY,StrId::STR_KAKURO_RESTART,StrId::STR_KAKURO_HOW_TO,StrId::STR_GAME_HOME};GUI.drawList(renderer,Rect{0,y,w,renderer.getScreenHeight()-y-m.buttonHintsHeight-8},state==State::Levels?3:MenuCount,selected,[&](int i){return std::string(state==State::Levels?difficultyName(static_cast<KakuroBoard::Difficulty>(i)):I18N.get(ids[i]));});buttons(tr(STR_BACK),tr(STR_SELECT),tr(STR_DIR_UP),tr(STR_DIR_DOWN));}
std::string KakuroGameActivity::helpText()const{return tr(STR_KAKURO_RULES);}
void KakuroGameActivity::renderText(){const auto&m=UITheme::getInstance().getMetrics();int w=renderer.getScreenWidth(),top=m.topPadding+m.headerHeight+12,lh=renderer.getLineHeight(small);const char*title=I18N.get(state==State::Rules?StrId::STR_KAKURO_HOW_TO:state==State::Combinations?StrId::STR_KAKURO_COMBINATIONS:StrId::STR_KAKURO_RESTART);GUI.drawHeader(renderer,Rect{0,m.topPadding,w,m.headerHeight},title);std::string text=state==State::Rules?helpText():state==State::Combinations?runText(true)+"\n\n"+runText(false):tr(STR_KAKURO_RESTART_QUESTION);auto lines=renderer.wrappedText(small,text.c_str(),w-40,1000);int count=std::max(1,(renderer.getScreenHeight()-m.buttonHintsHeight-top-10)/lh);scroll=std::clamp(scroll,0,std::max(0,int(lines.size())-count));for(int i=scroll;i<int(lines.size())&&i<scroll+count;++i)renderer.drawText(small,20,top+(i-scroll)*lh,lines[i].c_str());buttons(tr(STR_BACK),state==State::ConfirmRestart?tr(STR_SELECT):tr(STR_DIR_DOWN),tr(STR_DIR_UP),tr(STR_DIR_DOWN));}
void KakuroGameActivity::renderWon(){drawHeader();int y=renderer.getScreenHeight()/2-70;renderer.drawCenteredText(UI_12_FONT_ID,y,tr(STR_KAKURO_SOLVED),true,EpdFontFamily::BOLD);renderer.drawCenteredText(small,y+50,tr(STR_KAKURO_NEXT_PROMPT));buttons(tr(STR_GAME_HOME),tr(STR_KAKURO_NEXT),"","");}
